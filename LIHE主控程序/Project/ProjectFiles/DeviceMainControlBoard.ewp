# IAR project DeviceMainControlBoard.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F40_41xxx; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\UCOS3.07\BSP; ..\..\UCOS3.07\uC-CPU\Port; ..\..\UCOS3.07\uC-CPU\Source; ..\..\UCOS3.07\uC-LIB; ..\..\UCOS3.07\uCOS-III\Port; ..\..\UCOS3.07\uCOS-III\Source; ..\..\CommonFunc; ..\..\CommonFunc\Can2Protocol; ..\..\CommonFunc\Can2SubSystem; ..\..\CommonFunc\SystemUtil; ..\..\Driver\DriverBoard; ..\..\Driver\DriverMCU; ..\..\Driver\DriverCore\CMSIS; ..\..\Driver\DriverCore\Startup; ..\..\Driver\DriverCore\StdLib\inc; ..\..\Driver\DriverCore\StdLib\src; ..\..\Driver\DriverCore\StdLibSupport; ..\..\Driver\DriverCore\UtilFunc; ..\DriverConfig\BoardConfig; ..\DriverConfig\CoreConfig; ..\DriverConfig\UCOS_Config; ..\DriverConfig\UserConfig; ..\TaskMain; ..\TaskMain\TaskApp; ..\TaskMain\TaskApp\TestProcess; ..\TaskMain\TaskService; ..\TaskMain\TaskService\ActionImplement; ..\TaskMain\TaskServiceCall; ..\TaskMain\TaskUtil; ..\UserFunc; ..\..\CommonFunc\Can1Protocol
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Imm_Main_Vxx.xx.bin
  ILINK.IlinkOutputFile: MAIN_BOARD_Vxx.xx_H200.out
  ILINK.IlinkIcfFile: ..\..\Driver\DriverCore\Startup\stm32f407xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CommonFunc
    ../../CommonFunc/: ADT_CircleByteQueue.c ADT_CircleByteQueue.h ErrorCode.h SystemCmd.h UserMemManager.c UserMemManager.h
  group CommonFunc/Can1Protocol
    ../../CommonFunc/Can1Protocol/: Can1DataType.h
  group CommonFunc/Can2Protocol
    ../../CommonFunc/Can2Protocol/: Can2DataType.h Can2ProcConfig.h Can2ProcMain.c Can2ProcMain.h Can2ProcUtil.c Can2ProcUtil.h
  group CommonFunc/Can2SubSystem
    ../../CommonFunc/Can2SubSystem/: Can2SubInc.h Can2SubInputIndex.h Can2SubInputRead.c Can2SubInputRead.h Can2SubNeedleLiquidDetectCommon.h Can2SubNeedleReagentLiquidDetect.c Can2SubNeedleReagentLiquidDetect.h Can2SubNeedleSampleLiquidDetect.c Can2SubNeedleSampleLiquidDetect.h Can2SubOtherUtil.c Can2SubOtherUtil.h Can2SubOutputIndex.h Can2SubOutputWrite.c Can2SubOutputWrite.h Can2SubParam.c Can2SubParam.h Can2SubParamIndex.h Can2SubPhotonCount.c Can2SubSerial.c Can2SubSerial.h Can2SubSerialIndex.h Can2SubStepMotor.c Can2SubStepMotor.h Can2SubStepMotorIndex.h
  group CommonFunc/SystemUtil
    ../../CommonFunc/SystemUtil/: SystemInput.c SystemInput.h SystemInputIndex.h SystemOutput.c SystemOutput.h SystemOutputIndex.h
  group Driver/DriverBoard
    ../../Driver/DriverBoard/: BoardBeep.c BoardBeep.h BoardInc.h BoardInOut.c BoardInOut.h BoardIS62.c BoardIS62.h BoardLed.c BoardLed.h BoardMB85RS2MT.c BoardMB85RS2MT.h BoardPressure.c BoardPressure.h BoardRS.c BoardRS.h BoardSDCard.c BoardSDCard.h
  group Driver/DriverCore/CMSIS
    ../../Driver/DriverCore/CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group Driver/DriverCore/Startup
    ../../Driver/DriverCore/Startup/: startup_stm32f40_41xxx.s stm32f407xG.icf
  group Driver/DriverCore/StdLib/inc
    ../../Driver/DriverCore/StdLib/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_crc.h stm32f4xx_dac.h stm32f4xx_dma.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group Driver/DriverCore/StdLib/src
    ../../Driver/DriverCore/StdLib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Driver/DriverCore/StdLibSupport
    ../../Driver/DriverCore/StdLibSupport/: stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.h system_stm32f4xx.h
  group Driver/DriverCore/UtilFunc
    ../../Driver/DriverCore/UtilFunc/: CoreDelay.c CoreDelay.h CoreInc.h CoreUtil.c CoreUtil.h
  group Driver/DriverMCU
    ../../Driver/DriverMCU/: MCU_ADC.c MCU_ADC.h MCU_Can.c MCU_Can.h MCU_Inc.h MCU_internalFlash.c MCU_internalFlash.h MCU_Port.c MCU_Port.h MCU_Random.c MCU_Random.h MCU_SDIO.c MCU_SDIO.h MCU_SPI.c MCU_SPI.h MCU_Timer.c MCU_Timer.h MCU_Uart1.c MCU_Uart1.h MCU_Uart2.c MCU_Uart2.h MCU_Uart3.c MCU_Uart3.h MCU_Uart6.c MCU_Uart6.h MCU_UartCommon.h MCU_WDG.c MCU_WDG.h
  group Project/DriverConfig/BoardConfig
    ../DriverConfig/BoardConfig/: BoardInOutConfig.c BoardInOutConfig.h
  group Project/DriverConfig/CoreConfig
    ../DriverConfig/CoreConfig/: CoreNVIC_Prio.h stm32f4xx_it.c system_stm32f4xx.c
  group Project/DriverConfig/UCOS_Config
    ../DriverConfig/UCOS_Config/: cpu_cfg.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group Project/DriverConfig/UserConfig
    ../DriverConfig/UserConfig/: UserConfigInc.h UserMemManagerConfig.h
  group Project/TaskMain
    ../TaskMain/: SystemMain.c SystemTaskConfig.h TaskStart.c
  group Project/TaskMain/TaskApp
    ../TaskMain/TaskApp/: TaskAppConfig.h TaskAppTestProcess.c TaskAppTestProcess.h
  group Project/TaskMain/TaskApp/TestProcess
    ../TaskMain/TaskApp/TestProcess/: TestProc_API.h TestProc_boardID.H TestProc_canCommand.h TestProc_CanConfig.h TestProc_CupStack.c TestProc_CupStack.h TestProc_dlist.c TestProc_dlist.h TestProc_HandCup.c TestProc_HandCup.h TestProc_React.c TestProc_React.h TestProc_Reagent.c TestProc_Reagent.h TestProc_ReagentDisk.c TestProc_ReagentDisk.h TestProc_Result.h TestProc_Sample.c TestProc_Sample.h TestProc_testData.c TestProc_TestData.h TestProc_Typedef.h TestProc_Warning.c TestProc_Warning.h TestProc_Wash.c TestProc_Wash.h
  group Project/TaskMain/TaskService
    ../TaskMain/TaskService/: TaskServiceCan1Recv.c TaskServiceCan2Recv.c TaskServiceConfig.h TaskServiceCupStackManagement.c TaskServiceDebug.c TaskServiceDishReactionAndMixReagent.c TaskServiceDishReagent.c TaskServiceDishWashAndMixLiquidA.c TaskServiceHandCup.c TaskServiceHeart.c TaskServiceLiquidAutoProc.c TaskServiceLiquidInjectA.c TaskServiceMeasureRoomAndLiquidB.c TaskServiceMixBead.c TaskServiceNeedleReagentAndBead.c TaskServiceNeedleSample.c TaskServiceNeedleWash.c TaskServiceQRScan.c TaskServiceRankPathWay.c TaskServiceTemperatureControl.c TaskServiceUart3RS1Action.c
  group Project/TaskMain/TaskService/ActionImplement
    ../TaskMain/TaskService/ActionImplement/: ActionCommonBase.h ActionCupStackManagement.c ActionCupStackManagement.h ActionDishReactionAndMixReagent.c ActionDishReactionAndMixReagent.h ActionDishReagent.c ActionDishReagent.h ActionDishWashAndMixLiquidA.c ActionDishWashAndMixLiquidA.h ActionHandCup.c ActionHandCup.h ActionImplementInc.h ActionLiquidInjectA.c ActionLiquidInjectA.h ActionMeasureRoomAndLiquidB.c ActionMeasureRoomAndLiquidB.h ActionMixBead.c ActionMixBead.h ActionNeedleReagentAndBead.c ActionNeedleReagentAndBead.h ActionNeedleSample.c ActionNeedleSample.h ActionNeedleWash.c ActionNeedleWash.h ActionQRScan.c ActionQRScan.h ActionRankPathWay.c ActionRankPathWay.h ActionTemperatureControl.c ActionTemperatureControl.h
  group Project/TaskMain/TaskServiceCall
    ../TaskMain/TaskServiceCall/: TSC_Base.h TSC_CupStackManagement.c TSC_CupStackManagement.h TSC_Debug.c TSC_Debug.h TSC_DishReactionAndMixReagent.c TSC_DishReactionAndMixReagent.h TSC_DishReagent.c TSC_DishReagent.h TSC_DishWashAndMixLiquidA.c TSC_DishWashAndMixLiquidA.h TSC_HandCup.c TSC_HandCup.h TSC_Inc.h TSC_LiquidInjectA.c TSC_LiquidInjectA.h TSC_MeasureRoomAndLiquidB.c TSC_MeasureRoomAndLiquidB.h TSC_MixBead.c TSC_MixBead.h TSC_NeedleReagentAndBead.c TSC_NeedleReagentAndBead.h TSC_NeedleSample.c TSC_NeedleSample.h TSC_NeedleWash.c TSC_NeedleWash.h TSC_QRScan.c TSC_QRScan.h TSC_RankPathWay.c TSC_RankPathWay.h TSC_TemperatureControl.c TSC_TemperatureControl.h TSC_TestMode.c
  group Project/TaskMain/TaskUtil
    ../TaskMain/TaskUtil/: SystemConfig.c SystemConfig.h SystemCRC.c SystemCRC.h SystemMsg.c SystemParam.c SystemParam.h SystemUartRSUtil.c SystemUartRSUtil.h
  group UCOS3.07/BSP
    ../../UCOS3.07/BSP/: bsp_user.c bsp_user.h
  group UCOS3.07/uC-CPU/Port
    ../../UCOS3.07/uC-CPU/Port/: cpu.h cpu_a.asm cpu_c.c
  group UCOS3.07/uC-CPU/Source
    ../../UCOS3.07/uC-CPU/Source/: cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
  group UCOS3.07/uC-LIB
    ../../UCOS3.07/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group UCOS3.07/uCOS-III/Port
    ../../UCOS3.07/uCOS-III/Port/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOS3.07/uCOS-III/Source
    ../../UCOS3.07/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_trace.h os_type.h os_var.c
